options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_0
  id: variable
  parameters:
    comment: |-
      (COMMENT)
      Enable/Disable appropriate FFT/Freq. blocks.
    value: '0'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '1'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: 'null'
    samp_rate: samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ipovaric/repos/wireless_comm_lab/Lab2/Message.txt
    repeat: 'True'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: wxgui_fftsink2_0
  id: wxgui_fftsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: '0'
    fft_rate: '15'
    fft_size: '1024'
    freqvar: None
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: samp_rate
    title: FFT Plot
    type: complex
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {state: disabled}

connections:
- [analog_frequency_modulator_fc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_throttle_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
