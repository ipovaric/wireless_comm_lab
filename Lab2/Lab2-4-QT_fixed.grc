options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '256'
  states: {}
- name: variable_1
  id: variable
  parameters:
    comment: |-
      (COMMENT)
      Enable/Disable appropriate FFT/Freq. blocks.
    value: '0'
  states: {}
- name: variable_2
  id: variable
  parameters:
    comment: |-
      (COMMENT)
      "digital_ofdm_mod" is old/depreciated block.
      Use "ODFM Transmitter" if it is available.
    value: '0'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: short
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: short
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: short
  states: {state: disabled}
- name: blocks_short_to_char_0
  id: blocks_short_to_char
  parameters: {}
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: '"packet_len"'
    output_is_shifted: 'True'
    pilot_carriers: ((),)
    pilot_symbols: ((),)
    sync_words: ((),)
  states: {}
- name: digital_ofdm_mod_0
  id: digital_ofdm_mod
  parameters:
    cp_length: '128'
    fft_length: '1024'
    modulation: qam256
    occupied_tones: '200'
    pad_for_usrp: 'True'
    payload_length: '0'
    type: byte
  states: {state: disabled}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    log: 'True'
    packet_len_key: length
    payload_mod: '"BPSK"'
    rolloff: '0'
  states: {}
- name: digital_ofdm_tx_1
  id: digital_ofdm_tx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    packet_len_key: length
    payload_mod: '"BPSK"'
    rolloff: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: wxgui_fftsink2_0
  id: wxgui_fftsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: '0'
    fft_rate: '1'
    fft_size: '1024'
    freqvar: None
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: samp_rate
    title: FFT Plot
    type: complex
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {state: disabled}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_delay_0, '0', blocks_short_to_char_0, '0']
- [blocks_short_to_char_0, '0', digital_ofdm_mod_0, '0']
- [blocks_short_to_char_0, '0', digital_ofdm_tx_0, '0']
- [blocks_throttle_0, '0', digital_ofdm_tx_0, '0']
- [digital_ofdm_mod_0, '0', wxgui_fftsink2_0, '0']
- [digital_ofdm_tx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
