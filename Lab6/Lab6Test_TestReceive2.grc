options:
  parameters:
    generate_options: qt_gui
    id: Lab6TestModulate
    output_language: python
    title: Lab6TestModulate
  states: {}

blocks:
- name: constellation
  id: variable
  parameters:
    value: '2'
  states: {}
- name: flow_id
  id: variable
  parameters:
    value: '2'
  states: {}
- name: packing
  id: variable
  parameters:
    value: '4'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500'
  states: {}
- name: L6_receiver_pkt_receiver_0
  id: L6_receiver_pkt_receiver
  parameters:
    flow_id: flow_id
    payload_size: payload_size
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_1_0_1_0
  id: blocks_file_sink
  parameters:
    file: received_after.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: received_unpkt.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1,5,5
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [L6_receiver_pkt_receiver_0, '0', blocks_char_to_float_0, '0']
- [L6_receiver_pkt_receiver_0, '0', blocks_file_sink_1_0_1_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', L6_receiver_pkt_receiver_0, '0']

metadata:
  file_format: 1
