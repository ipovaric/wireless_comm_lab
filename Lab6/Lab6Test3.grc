options:
  parameters:
    generate_options: qt_gui
    id: Lab6Test2
    output_language: python
    title: Lab6Test3
  states: {}

blocks:
- name: flow_id
  id: variable
  parameters:
    value: '1'
  states: {}
- name: noise_level
  id: variable
  parameters:
    value: '3'
  states: {}
- name: packing
  id: variable
  parameters:
    value: '4'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_level
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: int
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '10'
    min: '5'
    num_samps: '100'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: received.txt
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: samp_rate*5
    type: byte
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: samp_rate*2
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: demo2_pkt_receiver_0
  id: demo2_pkt_receiver
  parameters: {}
  states: {state: disabled}
- name: demo_pkt_framer_0
  id: demo_pkt_framer
  parameters:
    flow_id: flow_id
    payload_size: payload_size
  states: {}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: packing
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: packing
    timing_bw: 6.28/100.0
  states: {state: disabled}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: packing
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: packing
  states: {state: disabled}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_1_0, '0']
- [blocks_throttle_0, '0', demo_pkt_framer_0, '0']
- [demo_pkt_framer_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_psk_mod_0, '0', digital_psk_demod_0, '0']

metadata:
  file_format: 1
