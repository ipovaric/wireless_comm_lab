options:
  parameters:
    generate_options: qt_gui
    id: Lab6Test2
    output_language: python
    title: Lab6Test3
  states: {}

blocks:
- name: flow_id
  id: variable
  parameters:
    value: '1'
  states: {}
- name: packing
  id: variable
  parameters:
    value: '2'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: L6_receiver_pkt_receiver_0
  id: L6_receiver_pkt_receiver
  parameters:
    flow_id: flow_id
    payload_size: payload_size
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '22'
    min: '20'
    num_samps: '10'
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_sink_1_0_0
  id: blocks_file_sink
  parameters:
    file: received.txt
    type: byte
  states: {}
- name: blocks_file_sink_1_0_1
  id: blocks_file_sink
  parameters:
    file: received_unpkt.txt
    type: byte
  states: {}
- name: blocks_file_sink_1_0_1_0
  id: blocks_file_sink
  parameters:
    file: received_after.txt
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: samp_rate*10
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '4'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: demo_pkt_framer_0
  id: demo_pkt_framer
  parameters:
    flow_id: flow_id
    payload_size: payload_size
  states: {}

connections:
- [L6_receiver_pkt_receiver_0, '0', blocks_file_sink_1_0_1_0, '0']
- [analog_random_source_x_0_0, '0', demo_pkt_framer_0, '0']
- [blocks_head_0, '0', blocks_file_sink_1_0_0, '0']
- [blocks_head_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', L6_receiver_pkt_receiver_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_file_sink_1_0_1, '0']
- [demo_pkt_framer_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
