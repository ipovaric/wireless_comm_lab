options:
  parameters:
    generate_options: qt_gui
    id: Lab6TestModulate
    output_language: python
    title: Lab6TestModulate
  states: {}

blocks:
- name: constellation
  id: variable
  parameters:
    value: '2'
  states: {}
- name: flow_id
  id: variable
  parameters:
    value: '1'
  states: {}
- name: packing
  id: variable
  parameters:
    value: '4'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100'
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '22'
    min: '20'
    num_samps: '10'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {state: disabled}
- name: blocks_file_sink_1_0_0
  id: blocks_file_sink
  parameters:
    file: sent.txt
    type: byte
  states: {}
- name: blocks_file_sink_1_0_1
  id: blocks_file_sink
  parameters:
    file: received_unpkt.txt
    type: byte
  states: {}
- name: blocks_file_sink_1_0_1_1
  id: blocks_file_sink
  parameters:
    file: received_pkt4.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1_0_1_1_0
  id: blocks_file_sink
  parameters:
    file: received_pkt6.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1_0_1_1_0_0
  id: blocks_file_sink
  parameters:
    file: received_pkt8.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1_0_1_1_0_0_0
  id: blocks_file_sink
  parameters:
    file: received_pkt10.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1_0_1_1_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: received_pkt12.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1_0_1_1_1
  id: blocks_file_sink
  parameters:
    file: received_pkt2.txt
    type: byte
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '500'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '4'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '6'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0_1_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0_1_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '10'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0_1_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '12'
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '4'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: demo_pkt_framer_0
  id: demo_pkt_framer
  parameters:
    flow_id: flow_id
    payload_size: payload_size
  states: {}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: constellation
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: packing
    timing_bw: 6.28/100.0
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: constellation
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: packing
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '500'
    srate: samp_rate
    type: float
    ymax: '5'
  states: {state: disabled}

connections:
- [analog_random_source_x_0_0, '0', blocks_head_0, '0']
- [blocks_char_to_float_0, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_head_0, '0', blocks_throttle_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_1_0_1_1, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', blocks_file_sink_1_0_1_1_1, '0']
- [blocks_pack_k_bits_bb_0_0_1, '0', blocks_file_sink_1_0_1_1_0, '0']
- [blocks_pack_k_bits_bb_0_0_1_0, '0', blocks_file_sink_1_0_1_1_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_1_0_0, '0', blocks_file_sink_1_0_1_1_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_1_0_0_0, '0', blocks_file_sink_1_0_1_1_0_0_0_0, '0']
- [blocks_throttle_0, '0', demo_pkt_framer_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [demo_pkt_framer_0, '0', blocks_file_sink_1_0_0, '0']
- [demo_pkt_framer_0, '0', digital_psk_mod_0, '0']
- [digital_psk_demod_0, '0', blocks_file_sink_1_0_1, '0']
- [digital_psk_mod_0, '0', digital_psk_demod_0, '0']

metadata:
  file_format: 1
