options:
  parameters:
    generate_options: qt_gui
    id: Lab6Test2
    output_language: python
    title: Lab6Test3
  states: {}

blocks:
- name: flow_id
  id: variable
  parameters:
    value: '1'
  states: {}
- name: packing
  id: variable
  parameters:
    value: '2'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100'
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '22'
    min: '20'
    num_samps: '100'
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_1_0_0
  id: blocks_file_sink
  parameters:
    file: sent.txt
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: demo_pkt_framer_0
  id: demo_pkt_framer
  parameters:
    flow_id: flow_id
    payload_size: payload_size
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1,5,5
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_random_source_x_0_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', demo_pkt_framer_0, '0']
- [demo_pkt_framer_0, '0', blocks_char_to_float_0, '0']
- [demo_pkt_framer_0, '0', blocks_file_sink_1_0_0, '0']

metadata:
  file_format: 1
