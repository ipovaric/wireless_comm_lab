options:
  parameters:
    generate_options: qt_gui
    id: Lab6Test2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: noise_level
  id: variable
  parameters:
    value: '3'
  states: {}
- name: packing
  id: variable
  parameters:
    value: '2'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '5'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_level
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: int
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '8'
    min: '5'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: received2.txt
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: samp_rate*3
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: packing
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: samp_rate*2
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: demo2_pkt_receiver_0
  id: demo2_pkt_receiver
  parameters: {}
  states: {state: disabled}
- name: demo_pkt_framer_0
  id: demo_pkt_framer
  parameters:
    flow_id: '1'
    payload_size: payload_size
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_char_0, '0']
- [blocks_float_to_char_0, '0', demo_pkt_framer_0, '0']
- [blocks_head_0, '0', blocks_file_sink_1_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_head_0, '0']
- [demo_pkt_framer_0, '0', blocks_pack_k_bits_bb_0, '0']

metadata:
  file_format: 1
