options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: sim
    output_language: python
    run_options: run
  states: {}

blocks:
- name: a1
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: a1
    start: '-2'
    step: '0.1'
    stop: '2'
    value: '0.5'
  states: {state: disabled}
- name: a1
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: a2
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: a2
    start: '-2'
    step: '0.1'
    stop: '2'
    value: '0.5'
  states: {state: disabled}
- name: a2
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: epsilon
  id: variable
  parameters:
    value: '0.00005'
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    start: '-.001'
    step: '0.0001'
    stop: '.001'
    value: '0'
  states: {state: disabled}
- name: filename
  id: variable
  parameters:
    value: ' "results/sim_%d_%d_%.1f_.pcap" % (repetition, encoding, snr)'
  states: {}
- name: foffset
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: FreqOffset
    start: '-0.1'
    step: '0.01'
    stop: '0.1'
    value: '0'
  states: {state: disabled}
- name: foffset
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {state: disabled}
- name: noise
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: snr
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    start: '-15'
    step: '0.1'
    stop: '30'
    value: '15'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: filename
    type: byte
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("".join("x" for i in range(pkt_length-24)))
    period: '5'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (10**(snr/10.0))**.5
    type: complex
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: 1.00+epsilon
    freq_offset: foffset
    noise_voltage: noise
    seed: '0'
    taps: a1+a2*1j
  states: {}
- name: channels_channel_model_0_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.00'
    freq_offset: '0'
    noise_voltage: noise
    seed: '0'
    taps: '1'
  states: {state: disabled}
- name: encoding
  id: parameter
  parameters:
    comment: |-
      0, 1, ..., 6, 7
      corresponds to BPSK 1/2, ..., 64-QAM 3/4
    short_id: e
    type: intx
    value: '3'
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: out_buf_size
    pad_front: '1000'
    pad_tail: '1000'
  states: {}
- name: foo_random_periodic_msg_source_0
  id: foo_random_periodic_msg_source
  parameters:
    debug: 'False'
    interval: '5'
    msg_len: pkt_length - 24
    num: messages
    quit: 'True'
    seed: repetition
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]'
    dst_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    src_mac: '[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import random
  states: {}
- name: messages
  id: parameter
  parameters:
    comment: Number of messages to generate
    short_id: n
    type: intx
    value: '10'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: pkt_length
    type: complex
  states: {state: disabled}
- name: pkt_length
  id: parameter
  parameters:
    comment: Packet size (in byte)
    short_id: l
    type: intx
    value: '133'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,1,2
    size: 48*10
    type: complex
  states: {state: disabled}
- name: repetition
  id: parameter
  parameters:
    comment: Current repetition of experiment.
    short_id: r
    type: intx
    value: '23'
  states: {}
- name: snr
  id: parameter
  parameters:
    comment: Signal to Noise Ratio
    short_id: s
    type: eng_float
    value: '10'
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: 10e6
    chan_est: ieee802_11.LS
    encoding: encoding
    frequency: 5.89e9
    sensitivity: '0.56'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, ieee802_11_mac_0, app in]
- [blocks_multiply_const_vxx_0, '0', channels_channel_model_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', channels_channel_model_0_0_0, '0']
- [channels_channel_model_0_0, '0', wifi_phy_hier_0, '0']
- [channels_channel_model_0_0_0, '0', wifi_phy_hier_0, '0']
- [foo_packet_pad2_0, '0', blocks_multiply_const_vxx_0, '0']
- [foo_random_periodic_msg_source_0, out, ieee802_11_mac_0, app in]
- [foo_wireshark_connector_0, '0', blocks_file_sink_0_0, '0']
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']
- [wifi_phy_hier_0, '0', foo_packet_pad2_0, '0']
- [wifi_phy_hier_0, carrier, pdu_pdu_to_tagged_stream_0, pdus]
- [wifi_phy_hier_0, mac_out, foo_wireshark_connector_0, in]

metadata:
  file_format: 1
