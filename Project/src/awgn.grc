options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: sim
    output_language: python
    run_options: run
  states: {}

blocks:
- name: filename
  id: variable
  parameters:
    value: ' "results/sim_%d_%d_%.1f_.pcap" % (repetition, encoding, snr)'
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: repetition
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: filename
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (10**(snr/10.0))**.5
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: encoding
  id: parameter
  parameters:
    comment: |-
      0, 1, ..., 6, 7
      corresponds to BPSK 1/2, ..., 64-QAM 3/4
    short_id: e
    type: intx
    value: '1'
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: out_buf_size
    pad_front: '1000'
    pad_tail: '1000'
  states: {}
- name: foo_random_periodic_msg_source_0
  id: foo_random_periodic_msg_source
  parameters:
    debug: 'False'
    interval: '5'
    msg_len: pdu_len - 24
    num: messages
    quit: 'False'
    seed: repetition
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]'
    dst_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    src_mac: '[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import random
  states: {}
- name: messages
  id: parameter
  parameters:
    comment: Number of messages to generate
    short_id: n
    type: intx
    value: '1000'
  states: {}
- name: pdu_len
  id: parameter
  parameters:
    comment: Packet size (in byte)
    short_id: l
    type: intx
    value: '133'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: repetition
  id: parameter
  parameters:
    comment: Current repetition of experiment.
    short_id: r
    type: intx
    value: '23'
  states: {}
- name: snr
  id: parameter
  parameters:
    comment: Signal to Noise Ratio
    short_id: s
    type: eng_float
    value: '10'
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: 10e6
    chan_est: ieee802_11.LS
    encoding: encoding
    frequency: 5.89e9
    sensitivity: '0.56'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0, '0', wifi_phy_hier_0, '0']
- [foo_packet_pad2_0, '0', blocks_multiply_const_vxx_0, '0']
- [foo_random_periodic_msg_source_0, out, ieee802_11_mac_0, app in]
- [foo_wireshark_connector_0, '0', blocks_file_sink_0_0, '0']
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [wifi_phy_hier_0, '0', foo_packet_pad2_0, '0']
- [wifi_phy_hier_0, '0', qtgui_time_sink_x_0, '0']
- [wifi_phy_hier_0, mac_out, foo_wireshark_connector_0, in]

metadata:
  file_format: 1
